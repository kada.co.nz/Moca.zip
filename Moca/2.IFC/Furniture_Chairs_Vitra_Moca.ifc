Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-19T17:04:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 19 17:04:44 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{1461CB64-4BF5-4138-B74E-B2123820A612}\ifc * Database version: 5507 * Database creation date: Fri Jun 19 17:04:42 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 19 17:04:43 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 19 17:04:43 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Moca, Furniture_Chairs_Vitra_Moca:Moca:327808
In: Level 1
Type - Material: 01 chrome, Wood dark oak with protective vanish 04
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs_Vitra_Moca; ConvergoRefNr: 0089-2006-0003-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Jasper Morrison continues his 'super normal' design approach with Moca, combining an understated aesthetic with robust high-quality materials to create an extremely durable chair.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_48; Version: 1; VersionDate: 17/06/2020
Type - Identity Data(Type) - Collection: Moca; Cost: 0; Description: Jasper Morrison continues his 'super normal' design approach with Moca, combining an understated aesthetic with robust high-quality materials to create an extremely durable chair.; Designer: Jasper Morrison; Manufacturer: Vitra; Model: Moca; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/3521234/storage/master/download/Factsheet%20Moca-EN.pdf; Type Name: Moca; URL: https://www.vitra.com/en-un/living/product/details/moca
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_Moca; Features: Stackable.; Finish: Seat and backrest: moulded plywood veneer in natural oak (Germany) or dark-stained oak (USA), protective natural lacquer finish. Base: stackable metal base (up to 6 chairs), chrome-plated or powder-coated finish.; Grade: n/a; Material: Polyurethane, fabric or leather, wood & steel.; ModelNumber: 09189202; ModelReference: n/a; Name: Vitra_Moca; ReplacementCost: n/a; Shape: Sculptured; Size: 505x485x790 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.01859 m2; Volume: 0.19113 m3
Materials and Finishes - ChairMainMaterial: Wood dark oak with protective vanish 04; ChairSecondaryMaterial: 01 chrome
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_Moca: Moca; Family and Type: Furniture_Chairs_Vitra_Moca: Moca; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_Moca: Moca; Type Id: Furniture_Chairs_Vitra_Moca: Moca; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
